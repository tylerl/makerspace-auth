# Repository tylerl/makerspace-auth

## KiCad design hardware/pi-hat-1/ms_auth_breakout.kicad_pcb

Board: 2 copper layers, 65.5 x 57.8 mm, 41 parts (0 on the bottom side), 37 nets.

Parts:
@HOLE0, @HOLE1, @HOLE2: (no value)
C2: 47u; C1206
D1, D2, D3, D4: DIODE-DO-214AC; DO-214AC
IC1: ULN2003AD; SO16
J1, J2, J3, J4: CONN_05POLAR_LOCK; MOLEX-1X5_LOCK
J5: CONN_06POLAR_LOCK; MOLEX-1X6_LOCK
J7: CONN_03POLAR_LOCK; MOLEX-1X3_LOCK
J8: CONN_04POLAR_LOCK; MOLEX-1X4_LOCK
J9: POWER_JACKPTH_LOCK; POWER_JACK_PTH_LOCK
J10, J12, J13: CONN_02POLAR_LOCK; MOLEX-1X2_LOCK
J11: BUCK_MODULEHORIZONTAL; BUCK_HORIZONTAL
J14: PINHD-2X20; 2X20
LED1, LED2: LED; CHIPLED_0805
LOGO1: OSHW-LOGOM; OSHW-LOGO-M
Q1, Q2, Q3, Q4, Q5, Q6: DMN3023L; SOT23-3
R1: 1k; R0805
R2: 560; R0805
R3, R4, R5, R6: 10k; R0805
RL1, RL2: HFD23_SPDT; HFD23
U$1: MS_LOGO; MS_LOGO_VECTOR
U$2: US0093; CERT-SMALL-SILK

Connections:
+5V: J11.OUT, J14.2, J14.4, R2.2
+12V: C2.1, D1.C, D2.C, D3.C, D4.C, IC1.9, J1.4, J2.4, J3.4, J4.4, J5.5, J7.1, J8.1, J9.PWR, J10.2, J11.IN, R1.2, RL1.2, RL2.2
/B1_LOGIC: J1.1, J14.11
/B2_LOGIC: J2.1, J14.16
/B3_LOGIC: J3.1, J14.32
/B4_LOGIC: J4.1, J14.12
/B5_LOGIC: J5.2, J14.13
/B6_LOGIC: J5.1, J14.7, R5.2
/B_LOGIC: J14.18, Q3.1
/G_LOGIC: J14.22, Q2.1
/HC_LOGIC: J14.40, Q4.1, R6.2
/L1_LOGIC: IC1.7, J14.38
/L2_LOGIC: IC1.6, J14.37
/L3_LOGIC: IC1.5, J14.36
/L4_LOGIC: IC1.4, J14.35
/L5_LOGIC: IC1.3, J14.33
/L6_LOGIC: IC1.2, J14.31, Q5.1, R3.2
/L7_LOGIC: J14.29, Q6.1, R4.2
/R_LOGIC: J14.15, Q1.1
/~B: J8.4, Q3.3
/~G: J8.3, Q2.3
/~L1: IC1.10, J1.5
/~L2: IC1.11, J2.5
/~L3: IC1.12, J3.5
/~L4: IC1.13, J4.5
/~L5: IC1.14, J5.6
/~R: J8.2, Q1.3
GND: C2.2, D1.A, IC1.1, IC1.8, J1.3, J2.3, J3.3, J4.3, J5.4, J7.3, J9.GND, J9.GNDBREAK, J10.1, J11.GND, J14.20, J14.34, J14.39, LED1.C, LED2.C, Q1.2, Q2.2, Q3.2, Q4.2, Q5.2, Q6.2, R3.1, R4.1, R5.1, R6.1
unnamed: D2.A, Q6.3, RL2.5
unnamed: D3.A, Q5.3, RL1.5
unnamed: D4.A, J7.2, Q4.3
unnamed: J12.1, RL1.3
unnamed: J12.2, RL1.1
unnamed: J13.1, RL2.3
unnamed: J13.2, RL2.1
unnamed: LED1.A, R1.1
unnamed: LED2.A, R2.1

## Commit log

2019-01-25 dev - unfinished
2019-08-19 dev commit - status unknown

Notices in the files:
hardware/pi-hat-1/ms_auth_breakout.kicad_pcb:
CC-BY
